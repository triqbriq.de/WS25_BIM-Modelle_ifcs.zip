Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 6179efc5-99d9-4180-8e69-dbf50a19da6b, NumberOfSaves: 11], CoordinateReference [CoordinateBase: Internal Origin, ProjectSite: Internal], ExchangeRequirement [Architecture]
Time: 2025-09-10T12:27:26+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.2.0.49

# IfcSite, Default
RefLatitude: 45, 45, 37, 23925; RefLongitude: 21, 14, 26, 780090; RefElevation: 0 cm

# IfcBuildingStorey: Level:ABOVE SLAB__Symbols Both Ends (10)
Name | LongName | Elevation (cm)
B2__ABOVE Slab | B2__ABOVE Slab | -612
B1__ABOVE Slab | B1__ABOVE Slab | -312
L00__ABOVE Slab | L00__ABOVE Slab | -12
L01__ABOVE Slab | L01__ABOVE Slab | 273
L02__ABOVE Slab | L02__ABOVE Slab | 558
L03__ABOVE Slab | L03__ABOVE Slab | 843
L04__ABOVE Slab | L04__ABOVE Slab | 1128
L05__ABOVE Slab | L05__ABOVE Slab | 1413
L06__ABOVE Slab | L06__ABOVE Slab | 1698
L07__ABOVE Slab | L07__ABOVE Slab | 1983

# IfcColumn: Columns : wll_s__TIMBER BLOCK__Triqbriq, Full Width__wp : WS25
In: L00__ABOVE Slab
Type - PredefinedType: COLUMN; Material: _MASONRY__Timber Block__Triqbriq, X, _MASONRY__Timber Block__Triqbriq, Y
